require stone-ocean-kernel.inc
